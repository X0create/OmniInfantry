# Keil uVision project HAL_Template.uvprojx, settings and files
target HAL_Template (6220000::V6.22::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: HAL_Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_PRESENT=1U,ARM_MATH_CHECK
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Application/API/Inc;../Application/Tasks/Inc;../Bsp/Inc;../Components/Algorithm/Inc;../Components/Controller/Inc;../Components/Device/Inc;../Middlewares/ST/ARM/DSP/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/Task
    ../Application/Tasks/Src/: Detect_Task.c INS_Task.c Vision_Task.c Comm_Task.c Gimbal_Task.c Shoot_Task.c
    ../Application/Tasks/Inc/: config.h
  group BSP
    ../Bsp/Src/: bsp_can.c bsp_dwt.c bsp_gpio.c bsp_mcu.c bsp_spi.c bsp_tick.c bsp_tim.c bsp_buzzer.c bsp_uart.c bsp_adc.c
  group Components/Algorithm
    ../Components/Algorithm/Src/: crc.c kalman.c lpf.c ramp.c quaternion.c rls.c fast_math.c
    ../Components/Algorithm/Inc/: fast_math.h
  group Components/Controller
    ../Components/Controller/Src/: pid.c SMC.c
  group Components/Device
    ../Components/Device/Src/: bmi088.c minipc.c motor.c remote_control.c referee_info.c image_transmission.c Keyboard.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c can.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_can.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Middlewares/Library/DSP Library/DSP Library
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4lf_math.lib arm_cortexM4l_math.lib
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
